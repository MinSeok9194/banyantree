<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RCS-300-RCU-SAMPLE(Ver 0.00).ewp</path>
  </project>
  <batchBuild/>
</workspace>


