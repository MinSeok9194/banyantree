# IAR project RCS-300-RCU-SAMPLE(Ver 0.00).ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG_2
  ICCARM.CCIncludePath2: ; ..\include\; ..\module\; app
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bbs.bin
  ILINK.IlinkOutputFile: bbs.out
  ILINK.IlinkIcfFile: I:\3. 2019년_MST-SYSTEM_220509\295. 반야트리-190508\101. Firmware-190917\IHS_Last_Version_2020_0102\RCS-300-RCU_(EURO)_(Rev0.17)_20200512\User\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: bbs_b427.bin
  group Include
    ../include/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_RTC.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Module
    ../module/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Module/App
    app/: 24lcxx.c 24lcxx.h bit_define.h iexec.c iexec.h main.c main.h stm32f10x_init.c stm32f10x_init.h stm32f10x_it.c stm32f10x_it.h stm32f10x_lib.h switch_io.c switch_io.h uart1.c uart1.h uart2.c uart2.h uart3.c uart3.h
  group User
    ./: bit_define.h cortexm3_macro.s stm32f10x_conf.h stm32f10x_flash.icf stm32f10x_flash_app.icf stm32f10x_vector.c
